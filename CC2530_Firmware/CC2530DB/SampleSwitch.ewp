# IAR project SampleSwitch.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; HOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; HOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS; HAL_MCU_CC2530=1; __ICC8051__
  ICC8051.PreInclude: zcl_app_config.h
  ICC8051.CCIncludePath2: D:\IAR\8051\inc; D:\IAR\8051\inc\dlib; D:\Z-Stack Home 1.2.2a.44539\Components\hal\include; D:\Z-Stack Home 1.2.2a.44539\Components\hal\target\CC2530EB; D:\Z-Stack Home 1.2.2a.44539\Components\mac\include; D:\Z-Stack Home 1.2.2a.44539\Components\mac\low_level\srf05; D:\Z-Stack Home 1.2.2a.44539\Components\mac\high_level; D:\Z-Stack Home 1.2.2a.44539\Components\mt; D:\Z-Stack Home 1.2.2a.44539\Components\services\saddr; D:\Z-Stack Home 1.2.2a.44539\Components\services\sdata; D:\Z-Stack Home 1.2.2a.44539\Components\stack\af; D:\Z-Stack Home 1.2.2a.44539\Components\stack\sapi; D:\Z-Stack Home 1.2.2a.44539\Components\stack\sec; D:\Z-Stack Home 1.2.2a.44539\Components\stack\sys; D:\Z-Stack Home 1.2.2a.44539\Components\stack\zcl; D:\Z-Stack Home 1.2.2a.44539\Components\stack\zdo; D:\Z-Stack Home 1.2.2a.44539\Components\zmac; D:\Z-Stack Home 1.2.2a.44539\Components\zmac\f8w; D:\Z-Stack Home 1.2.2a.44539\Projects\zstack\HomeAutomation\Source; D:\Z-Stack Home 1.2.2a.44539\Projects\zstack\ZMain\TI2530DB; D:\Z-Stack Home 1.2.2a.44539\Components\osal\include; D:\Z-Stack Home 1.2.2a.44539\Components\stack\nwk; D:\Z-Stack Home 1.2.2a.44539\Components\mac\low_level\srf05\single_chip; D:\Z-Stack Home 1.2.2a.44539\Components\driverlib\cc2538\inc; D:\IAR\SampleSwitch
  XLINK.XclFile: D:\Z-Stack Home 1.2.2a.44539\Projects\zstack\Tools\CC2530DB\f8w2530.xcl
configuration EndDeviceEB - OTAClient (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; ZCL_READ; ZCL_WRITE; ZCL_REPORT; xZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; OTA_CLIENT=TRUE; OTA_HA
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\OTA\Source
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "EndDeviceEB - OTAClient\Exe\EndDeviceEB-OTAClient.sim" -o"EndDeviceEB - OTAClient\Exe" -t0x1234 -m0x5678 -v0000ABCD -pCC2530DB
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\ota.xcl
configuration RouterEB - OTAClient (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; HOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; OTA_CLIENT=TRUE; OTA_HA
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "RouterEB - OTAClient\Exe\RouterEB-OTAClient.sim" -o"RouterEB - OTAClient\Exe" -t0x1234 -m0x5678 -v0000ABCD -pCC2530DB
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\ota.xcl
  group App
    ../Source/: OSAL_SampleSw.c zcl_samplesw.c zcl_samplesw.h zcl_samplesw_data.c
  group Profile
    $ZSTACK_HOME$/Projects/zstack/HomeAutomation/Source/: zcl_ha.c
    $EW_DIR$/Source/: zcl_ha.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.h
    $ZSTACK_HOME$/Projects/zstack/ZMain/TI2530DB/: OnBoard.c ZMain.c
